# Keil uVision project demo.uvproj, settings and files
target demo (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: demo
  AfterMake: fromelf.exe --bin -o ./demo.bin ./demo.axf
  c flags: Optim=3
  c include: ..\;.\Core;.\tpm;.\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x68000c00 size 0x400
  memory RVCT9: RAM 0x68000400 size 0x800
  memory RVCT10: RAM 0x68000000 size 0x400
  group startup
    ./Core/: startup.s
  group source
    ./: main.c system.c extend.c
  group header
    ./Core/: FTRX.h ctype.h
  group lib
    ./Core/: RockeyLibc.lib FTRX.lib
  group tpm
    ./tpm/: tpm_structures.h tpm_cmd_handler.c tpm_commands.h tpm_emulator.h tpm_startup.c tpm_data.h tpm_data.c types.h tpm_handles.h tpm_handles.c tpm_marshalling.c tpm_marshalling.h tpm_authorization.c tpm_context.c tpm_eviction.c tpm_owner.c tpm_storage.c tpm_crypto.c tpm_identity.c tpm_integrity.c
  group crypto
    ./crypto/: sha1.h hmac.c hmac.h sha1.c
